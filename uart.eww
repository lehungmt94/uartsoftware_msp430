<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\uartsoft.ewp</path>
  </project>
  <batchBuild/>
</workspace>


